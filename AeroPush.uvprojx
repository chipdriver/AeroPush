# Keil uVision project AeroPush.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: AeroPush
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: .\Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Lib\Libraries\CMSIS\Include;.\Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\User\Inc;.\FreeRTOS\Include;.\FreeRTOS\Config;.\FreeRTOS\Portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ./Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph
    ./Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group App_Main
    ./User/Src/: main.c app_main.c stm32f4xx_it.c
  group App_Task
    ./User/Src/: app_tasks.c
  group App_Service
    ./User/Src/: imu_service.c modem_service.c telemetry_service.c led_service.c debug_service.c
  group App_RTOS
    ./User/Src/: freertos_objects.c freertos_hook.c
  group App_Status
    ./User/Src/: app_status.c
  group BSP
    ./User/Src/: bsp_led.c bsp_debug_uart.c bsp_a7670e_uart.c debug_log.c delay.c bsp_i2c_soft.c
  group Drivers_MPU9250
    ./User/Src/: mpu9250_driver.c
  group FreeRTOS_Core
    ./FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ./FreeRTOS/Portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS_Heap
    ./FreeRTOS/Portable/MemMang/: heap_4.c
